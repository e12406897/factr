Commit message: post presentation version

File: src/factr_teleop/factr_teleop/urdf/factr_teleop_franka.urdf (robot description, URDF)
Before this commit: robot factr_teleop_franka, 8 links, 7 joints
Links:
- link link_7: mass 0.051 -> 0.0
